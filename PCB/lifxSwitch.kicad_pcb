# Repository MeldrumJon/ESP8266-Button

File README.md:

# ESP8266-Button

Battery-powered WiFi button.

Can be used as an [IFTTT](https://ifttt.com/) trigger through 
[Webhooks](https://ifttt.com/maker_webhooks) or to 
control LIFX smart lights through the 
[LIFX HTTP API](https://api.developer.lifx.com/) or 
[LIFX LAN Protocol](https://lan.developer.lifx.com/).

## Parts

- ESP8266-01 module
- Low quiescent current LDO 3.3V voltage regulator ([MCP1826S-3302E/AB](https://www.mouser.com/ProductDetail/579-MCP1826S-3302EAB))
- 4.7uF electrolytic capacitor
- 1uF electrolytic capacitor
- Momentary pushbutton switch
- SPDT mini slide switch, 3-pin, 2.54mm pin spacing
- 2x 1k resistors
- Battery holder for 3xAA or 3xAAA batteries
- Breakaway headers (optional, for ESP8266-01 module)
- 2-pin JST connector cables (optional, useful for buttons or batteries)
- Project Box 100x60x25 mm; inside dimensions: 96x56x23 mm

## Tools

- USB to TTL Serial **3.3V** adapter

## PCB

KiCAD files are in [the `hardware` Folder](./hardware).

## Assembled Box

## Programming

### Setup

1. [Install the ESP8266 Arduino Core](https://github.com/esp8266/Arduino#installing-with-boards-manager)
2. Open one of the projects in [src/](./src/) in Arduino IDE.
3. In Arduino IDE,
	- Set `Tools->Board` to "Generic ESP8266 Module".
	- Set `Tools->Port` to your USB TTL Serial Adapter.
4. Connect the serial adapter's TX signal to RX on the ESP8266, RX to TX and 
GND to GND.
5. Update the `WIFI_SSID`, `WIFI_PASSWORD` and any other variables/macros marked
"TODO" to match your WiFi settings.

### Uploading

1. Set the slide switch to hold GPIO0 low.
2. Upload the sketch.
3. Whenever esptool.py tries to connect, press the pushbutton (to momentarily
hold RST low).
4. Wait for esptool to finish programming the ESP8266.
5. Move the slide switch back to hold GPIO0 high.

## KiCad design PCB/lifxSwitch.kicad_pcb

Parts:
C1: 4.7u; CP_Radial_D5.0mm_P2.00mm
C2: 1u; CP_Radial_D5.0mm_P2.00mm
J1: Conn_01x02; SolderWirePad_1x02_P3.81mm_Drill1mm
J2: Conn_01x02; SolderWirePad_1x02_P3.81mm_Drill0.8mm
J3: Conn_01x02_Female; PinSocket_1x02_P2.54mm_Vertical
R1: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R2: 1.2k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
SW1: SW_SPDT; SPDT_THT_Slide_SW
U1: MCP1826S; TO-220-3_Horizontal_TabUp
U2: ESP-01v090; ESP-01

Connections:
+3V3: C2.1, R1.1, R2.1, U1.3 (VO), U2.3 (CH_PD), U2.7 (VCC)
/RX: U2.8 (URXD); also elsewhere on the board
/TX: U2.1 (UTXD); also elsewhere on the board
GND: C1.2, C2.2, J1.2, J2.2, SW1.3 (C), U1.2 (GND), U2.2 (GND); also elsewhere on the board
unnamed: J2.1, R1.2, U2.5 (RST)
unnamed: R2.2, SW1.1 (A)
unnamed: SW1.2 (B), U2.6 (GPIO0)
VCC: C1.1, J1.1, U1.1 (VI)

Board: 2 copper layers, 29.7 x 29.5 mm, 10 parts (0 on the bottom side), 8 nets.

Other parts of the board:
J4: Conn_01x03_Female; PinSocket_1x03_P2.54mm_Vertical

Their connections:
/RX: J4.1; also elsewhere on the board
/TX: J4.2; also elsewhere on the board
GND: J4.3; also elsewhere on the board

## Commit log

2018-11-06 Small Refactor
2018-11-09 Ability to send and receive service headers!
2018-11-11 Getting closer.
2019-07-03 Ability to read power from LIFX bulb
2019-07-04 Successfully Toggling Light
2019-07-27 Nearly done
2019-07-27 Switch working
2019-09-11 Working PCB v0.1
2019-09-11 Include 3rd Party Libraries
2019-09-12 Part list
2019-09-12 Add setup and programming instructions.
2019-09-12 Added assets
2019-10-22 Separate code, PCB into own folders
2019-11-16 Add IFTTT Webhooks Project
2019-11-16 Update Projects
2019-11-28 Add GND header, Label RX, TX, GPIO0 switch
2019-11-28 Small silkscreen update
2020-02-11 Descriptive names
2020-02-11 Reorganize
2020-02-23 Add LIFX HTTP
2020-02-23 Update Images
